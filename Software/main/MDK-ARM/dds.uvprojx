# Keil uVision project dds.uvprojx, settings and files
target dds (6140000::V6.14::ARMCLANG)
  device: STM32F746VGTx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.14.0
  cpu: IRAM(0x20000000-0x2004FFFF) IROM(0x8000000-0x80FFFFF)               CLOCK(12000000) FPU3(SFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: dds +hex
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F746xx
  c include: ../Inc;                                                                              ../Drivers/STM32F7xx_HAL_Driver/Inc;                                                                              ../Drivers/STM32F7xx_HAL_Driver/Inc/Legacy;                                                                              ../Drivers/CMSIS/Device/ST/STM32F7xx/Include;                                                                              ../Drivers/CMSIS/Include;                                                                              ..\MY_BSP;                                                                      ../Middlewares/Third_Party/FatFs/src;../Middlewares/Third_Party/ARM_CMSIS/CMSIS/Core/Include/;../Middlewares/Third_Party/ARM_CMSIS/CMSIS/Core_A/Include/;../Middlewares/Third_Party/ARM_CMSIS/CMSIS/DSP/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8040000 size 0xa0000
  memory RVCT9: RAM 0x20000000 size 0x50000
  group Application/MDK-ARM
    ./: startup_stm32f746xx.s
  group Application/User
    ./: audio.c
    ../Src/: main.c bsp_driver_sd.c sd_diskio.c fatfs.c fatfs_platform.c stm32f7xx_it.c stm32f7xx_hal_msp.c camera.c gpio.c sdio.c dsp.c led.c
    ../Inc/: camera.h configs.h audio.h gpio.h sdio.h board.h dsp.h led.h
  group Drivers/STM32F7xx_HAL_Driver
    ../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_cortex.c stm32f7xx_hal.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_exti.c stm32f7xx_hal_dcmi.c stm32f7xx_hal_dcmi_ex.c stm32f7xx_hal_i2s.c stm32f7xx_ll_sdmmc.c stm32f7xx_hal_sd.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32f7xx.c
  group BSP
    ../MY_BSP/: ov5640.c sccb.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c ccsbcs.c
  group Middlewares/CMSIS/CMSIS/DSP/Source
    ../Middlewares/Third_Party/ARM_CMSIS/CMSIS/DSP/Source/BasicMathFunctions/: BasicMathFunctions.c
    ../Middlewares/Third_Party/ARM_CMSIS/CMSIS/DSP/Source/CommonTables/: CommonTables.c
    ../Middlewares/Third_Party/ARM_CMSIS/CMSIS/DSP/Source/ComplexMathFunctions/: ComplexMathFunctions.c
    ../Middlewares/Third_Party/ARM_CMSIS/CMSIS/DSP/Source/ControllerFunctions/: ControllerFunctions.c
    ../Middlewares/Third_Party/ARM_CMSIS/CMSIS/DSP/Source/FastMathFunctions/: FastMathFunctions.c
    ../Middlewares/Third_Party/ARM_CMSIS/CMSIS/DSP/Source/FilteringFunctions/: FilteringFunctions.c
    ../Middlewares/Third_Party/ARM_CMSIS/CMSIS/DSP/Source/MatrixFunctions/: MatrixFunctions.c
    ../Middlewares/Third_Party/ARM_CMSIS/CMSIS/DSP/Source/StatisticsFunctions/: StatisticsFunctions.c
    ../Middlewares/Third_Party/ARM_CMSIS/CMSIS/DSP/Source/SupportFunctions/: SupportFunctions.c
    ../Middlewares/Third_Party/ARM_CMSIS/CMSIS/DSP/Source/TransformFunctions/: TransformFunctions.c
software components: CMSIS:CORE 5.4.0
